# Keil uVision project boule.uvproj, settings and files
target Simulation (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mangeur +hex
  c flags: Optim=1
  c define: STM32F10X_XL
  c include: .\h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./src/: GLCD_16bitIF_STM32.c main.c boule.c food.c
  group System
    ./src/: system_stm32f10x.c startup_stm32f10x_hd.s
  group Headers
    ./h/: ext_globales.h Font_6x8_h.h Font_16x24_h.h GLCD.h globales.h boule.h jeu.h food.h
target DebugInSitu (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: mangeur +hex
  c flags: Optim=1
  c define: STM32F10X_XL
  c include: .\h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
